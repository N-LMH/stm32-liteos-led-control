# Keil uVision project project.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,LOSCFG_BASE_CORE_USE_MULTI_LIST,STM32_THREAD_SAFE_STRATEGY=2
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../LiteOS/kernel/include;../LiteOS/kernel/base/include;../LiteOS/arch/arm/cortex_m/include;../LiteOS/targets
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s armlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: app_init.c hal_irq.c usart.c adc.c los_uart.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group LiteOS/Kernel
    ../LiteOS/kernel/base/: los_task.c los_swtmr.c los_sem.c los_mux.c los_queue.c los_event.c los_tick.c los_sortlink.c los_bitmap.c los_err.c los_misc.c los_printf.c los_hwi.c los_exc.c los_mp.c los_percpu.c los_stackinfo.c
    ../LiteOS/kernel/base/sched/sched_sq/: los_priqueue.c los_sched.c
    ../LiteOS/kernel/base/mem/bestfit_little/: los_memory.c los_heap.c
    ../LiteOS/kernel/init/: los_init.c
    ../LiteOS/arch/arm/cortex_m/src/: cpu.c task.c
    ../Core/Src/: dispatch_keil.s los_adapter.c
software components: CMSIS:CORE 4.3.0
